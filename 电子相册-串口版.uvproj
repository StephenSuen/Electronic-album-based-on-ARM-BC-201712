# Keil uVision project 电子相册-串口版.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2416 Samsung
  cpu: IRAM(0x40000000-0x4000FFFF) IROM(0x00000000-0x00007FFF) CPUTYPE(ARM926EJ-S)
  output: Mini2451_Demo
  AfterMake: fromelf.exe --bin -o BIN/@l.bin Objects/@l.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\main;.\startup;.\drivers;.\DELAY
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT6: RAM 0x31000000 size 0x5000000
  memory RVCT9: RAM 0x40000000 size 0x10000
  link misc: --diag_suppress=L6314
  group StartUp
    ./startup/: 2451init.s 2451slib.s
  group main
    ./main/: main.c clock.c
    ./DELAY/: delay.c
  group drivers
    ./drivers/: s3c2451_led.c s3c2451_gpio.c key.c s3c2451_uart.c s3c2451_irq.c s3c2451_it.c s3c2451_time.c ascii.c S3C2451_lcd.c 198_187_24.c 272_272_24.c 198_198_24.c chinese.c s3c2451_adc.c s3c2451_rtc.c 439_126_24.c 407_89_24.c 474_88_24.c 480_272_24.c 214_206_24.c
